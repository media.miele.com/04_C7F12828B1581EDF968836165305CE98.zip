Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 5a1aeae5-948e-4184-a434-15885ce32ce9, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-06T09:30:18+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11166010_NER_CVA7845_EDST-CLST:29784540_NER_11166010_CVA7845_EDST-CLST, (2)
In: Default
Type - Material: <Unnamed>, z_Miele_Design_Glass, z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 455 mm; Depth: 475 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 29784540_NER_11166010_CVA7845_EDST-CLST; sets with these values: 2

# IfcDistributionPort, Port_353187_1
Description: Flow; FlowDirection: SOURCEANDSINK
